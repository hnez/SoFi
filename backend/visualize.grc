<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>blocks_file_descriptor_source</key>
<param><key>id</key><value>blocks_file_descriptor_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fd</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>fft_len</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0_0</value></param>
<param><key>file</key><value>/home/leonard/Dokumente/Uni/Praktikum/Vertiefungsprojekt/Sofi/backend/doa_071116_18dbdc4_91.5MHz_2048.bin</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>fft_len</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>vlen</key><value>fft_len</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>1</value></param>
</block>
<block>
<key>blocks_stream_to_streams</key>
<param><key>id</key><value>blocks_stream_to_streams_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_streams</key><value>6</value></param>
<param><key>vlen</key><value>fft_len</value></param>
</block>
<block>
<key>blocks_stream_to_streams</key>
<param><key>id</key><value>blocks_stream_to_streams_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_streams</key><value>6</value></param>
<param><key>vlen</key><value>fft_len</value></param>
</block>
<block>
<key>blocks_stream_to_streams</key>
<param><key>id</key><value>blocks_stream_to_streams_0_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_streams</key><value>6</value></param>
<param><key>vlen</key><value>fft_len</value></param>
</block>
<block>
<key>blocks_stream_to_streams</key>
<param><key>id</key><value>blocks_stream_to_streams_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_streams</key><value>3</value></param>
<param><key>vlen</key><value>fft_len</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate*3*6</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fft_len</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>name</key><value>"Phase"</value></param>
<param><key>nconnections</key><value>6</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>fft_len</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>1.0</value></param>
<param><key>ymax</key><value>6.5</value></param>
<param><key>ymin</key><value>-6.5</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0_0</value></param>
<param><key>name</key><value>"Magnitude"</value></param>
<param><key>nconnections</key><value>6</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>fft_len</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>1.0</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0_1</value></param>
<param><key>name</key><value>"Variance"</value></param>
<param><key>nconnections</key><value>6</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>fft_len</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>1.0</value></param>
<param><key>ymax</key><value>0.00002</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<connection><source_block_id>blocks_file_descriptor_source_0</source_block_id><sink_block_id>blocks_stream_to_streams_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>blocks_stream_to_streams_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>4</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>5</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>4</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>5</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0_1</source_block_id><sink_block_id>qtgui_vector_sink_f_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0_1</source_block_id><sink_block_id>qtgui_vector_sink_f_0_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0_1</source_block_id><sink_block_id>qtgui_vector_sink_f_0_1</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0_1</source_block_id><sink_block_id>qtgui_vector_sink_f_0_1</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0_1</source_block_id><sink_block_id>qtgui_vector_sink_f_0_1</sink_block_id><source_key>4</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0_1</source_block_id><sink_block_id>qtgui_vector_sink_f_0_1</sink_block_id><source_key>5</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_1</source_block_id><sink_block_id>blocks_stream_to_streams_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_1</source_block_id><sink_block_id>blocks_stream_to_streams_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_1</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_stream_to_streams_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
